# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\Libraries\CMSIS\Include;..\SYSTEM\delay;..\SYSTEM\log_print;..\USER;..\HARDWARE;..\U8G2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c air32f10x_it.c
    ../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group HARDWARE
    ../HARDWARE/: oled.c spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/log_print/: log_print.c
  group CORE
    ../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_rcc.c air32f10x_dma.c air32f10x_spi.c air32f10x_usart.c air32f10x_gpio.c
  group U8G2
    ../U8G2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
