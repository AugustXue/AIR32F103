# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\AIR32F10xLib\inc;..\..\..\Libraries\CMSIS\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\log_print;..\USER;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c air32f10x_it.c
    ../../../Libraries/AIR32F10xLib/src/: system_air32f10x.c
  group HARDWARE
    ../HARDWARE/: mpu6050.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/log_print/: log_print.c
  group CORE
    ../../../Libraries/STARTUP/arm/: startup_air32f10x.s
  group FWLib
    ../../../Libraries/AIR32F10xLib/src/: misc.c air32f10x_rcc.c air32f10x_dma.c air32f10x_spi.c air32f10x_usart.c air32f10x_gpio.c air32f10x_i2c.c
